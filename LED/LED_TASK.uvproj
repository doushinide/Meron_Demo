# Keil uVision project LED_TASK.uvproj, settings and files
target LED_TASK (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LED_TASK +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: F:\Program Files\Keil_C51\C51\INC;.\User
  group Source Group 1
    ./: STARTUP.A51
    ./User/: main.c Timer.c
